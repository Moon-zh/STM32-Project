# Keil uVision project UCOSII-3.uvprojx, settings and files
target UCOSII-3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOSII-3 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\MALLOC;..\HARDWARE\RS485;..\HARDWARE\LED;..\HARDWARE\RTC;..\HARDWARE\TIMER;..\HARDWARE\VisualTFT;..\HARDWARE\IO;..\HARDWARE\GPS;..\HARDWARE\STMFLASH;..\HARDWARE\Emw3060;..\HARDWARE\md5\ipsec;..\HARDWARE\md5\core;..\HARDWARE\md5;..\HARDWARE\IWDG;..\HARDWARE\NeowayN21;..\HARDWARE\CRC16;..\HARDWARE\CGQ
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c ZoneCtrl.c UserCore.c UserHmi.c FlashDivide.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/VisualTFT/: cmd_queue.c hmi_driver.c hmi_user_uart.c
    ../HARDWARE/IO/: IO_BSP.c
    ../HARDWARE/GPS/: GPS.C
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/Emw3060/: Emw3060.c
    ../HARDWARE/md5/core/: md5.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/CGQ/: cgq.c
    ../HARDWARE/CRC16/: crc16.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_iwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: README.TXT
