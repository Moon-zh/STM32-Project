# Keil uVision project collection.uvprojx, settings and files
target collection (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: collection +hex
  c flags: Optim=7 v6Lang=4 v6LangP=4 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: -D__weak="__attribute__((weak))" -D__packed="__attribute__((__packed__))" -D__NOINLINE="__attribute__ ( (noinline) )"
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\RS485;..\HARDWARE\MALLOC;..\HARDWARE;..\HARDWARE\HDMI;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\ZoneCtrl;..\HARDWARE\IO;..\HARDWARE\RTC;..\HARDWARE\G405tf;..\HARDWARE\STMFLASH;..\HARDWARE\NeowayN21;..\HARDWARE\Emw3060;..\HARDWARE\md5;..\HARDWARE\ipsec
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/NeowayN21/: NeowayN21.c
    ../HARDWARE/Emw3060/: Emw3060.c
    ../HARDWARE/md5/core/: md5.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c
  group README
    ../: README.TXT
  group HDMI
    ../HARDWARE/HDMI/: hmi_driver.c hmi_user_uart.c cmd_queue.c
  group UCOSII
    ../UCOSII/PORT/: os_cpu_c.c os_dbg_r.c os_cpu_a.asm os_cpu.h
    ../UCOSII/CONFIG/: includes.h os_cfg.h
    ../UCOSII/CORE/: os_mutex.c os_q.c os_core.c os_flag.c os_mbox.c os_mem.c os_sem.c os_task.c os_time.c os_tmr.c
